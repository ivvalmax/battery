# Keil uVision project Bat.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c
  group inc
    ./: common.h main.h uart.h
software components: RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Timers 11.2.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, File System:CORE 6.13.6, CMSIS Driver:GPIO 1.2.0, CMSIS Driver:I2C 3.1.0, CMSIS Driver:SPI 3.0.0, CMSIS Driver:USART 3.0.0, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Graphics:CORE 6.10.8, Graphics:Demo:Bitmap 6.10.8, Graphics:Demo:ColorBar 6.10.8, Graphics:Demo:Graph 6.10.8
